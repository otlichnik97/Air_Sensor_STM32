# Keil uVision project AirSensor.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AirSensor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\AirSensor_Git;.\CMSIS;.\Src;.\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group CMSIS
    ./CMSIS/: core_cm3.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h startup_stm32f103xb.s stm32f103xb.h cmsis_version.h cmsis_compiler.h cmsis_armcc.h
